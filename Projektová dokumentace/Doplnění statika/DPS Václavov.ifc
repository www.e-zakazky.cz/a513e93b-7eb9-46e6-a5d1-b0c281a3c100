Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: dd566153-5493-4a68-8c22-8643769b71ed, VersionGUID: 151add82-fc61-44d8-88ca-35f2aaddd584, NumberOfSaves: 36], CoordinateReference [CoordinateBase: Sdílené souřadnice]
File name: DPS Václavov.ifc
Time: 2025-05-27T01:16:10+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.10.45 (CSY) - IFC 25.4.10.45

# IfcProject, ZDE ZADEJTE ČÍSLO PROJEKTU
LongName: ZDE ZADEJTE NÁZEV PROJEKTU; Phase: ZDE ZADEJTE STUPEŇ PD

# IfcSite, Default
RefLatitude: 49, 57, 7, 487182; RefLongitude: 14, 2, 0, 238494; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 11

# IfcBuildingStorey: Podlaží:0,000, 1NP
LongName: 1NP; Elevation: 0 mm

# IfcBuildingStorey: Podlaží:HHK (3)
Name | LongName | Elevation (mm)
HHK 1NP | HHK 1NP | -200
HHK 2NP | HHK 2NP | 2605
HHK 3NP | HHK 3NP | 5850

# IfcBuildingStorey: Podlaží:Podlaží (4)
Name | LongName | Elevation (mm)
Základy | Základy | -2300
2NP | 2NP | 2770
3NP | 3NP | 6000
Střecha-nové | Střecha-nové | 9095

# IfcBuildingStorey: Podlaží:SHK2 (3)
Name | LongName | Elevation (mm)
SHK 1NP | SHK 1NP | -400
SHK 2NP | SHK 2NP | 2355
SHK 3NP | SHK 3NP | 5600

# IfcBeam: Trám_Obdélníkový:250x450 (4)
In: 3NP
Type - PredefinedType: BEAM
Type - Pset_BeamCommon - LoadBearing: yes
Material: Beton prostý, C30/37
Pset_BeamCommon - IsExternal: no; Slope: 0 deg; Reference: 250x450
Pset_QuantityTakeOff - Reference: 250x450; sets with these values: 2
Name (Trám_Obdélníkový:250x450:...) | Span (mm)
521561 | 2315.02
521844 | 4405
522191 | 5960
522527 | 4390

# IfcBeam: Trám_Obdélníkový:250x500 (16)
Type - PredefinedType: BEAM
Type - Pset_BeamCommon - LoadBearing: yes
Material: Beton prostý, C30/37
Pset_BeamCommon - IsExternal: no; Slope: 0 deg; Reference: 250x500
Pset_QuantityTakeOff - Reference: 250x500; sets with these values: 2
Name (Trám_Obdélníkový:250x500:...) | In | Span (mm)
511633 | 2NP | 3740
511732 | 3NP | 3740
512216 | 2NP | 3690
512366 | 3NP | 3240
512495 | 2NP | 3468.15
512496 | 3NP | 3240
526350 | 3NP | 5990
526530 | 3NP | 3740
526761 | 3NP | 4950
526947 | 3NP | 4950
527234 | 3NP | 5990
528031 | 2NP | 6165
528365 | 2NP | 5990
528712 | 2NP | 3938.77
528911 | 2NP | 4950
529109 | 2NP | 4950

# IfcBeam: Trám_Obdélníkový:400x400 (5)
In: 2NP
Type - PredefinedType: JOIST
Type - Pset_BeamCommon - LoadBearing: yes
Material: Beton prostý, C30/37
Pset_BeamCommon - IsExternal: no; Slope: 0 deg; Reference: 400x400
Pset_QuantityTakeOff - Reference: 400x400; sets with these values: 2
Name (Trám_Obdélníkový:400x400:...) | Span (mm)
509847 | 6010
509932 | 6000
509954 | 6010
509963 | 6010
527700 | 6010

# IfcBeam: Trám_Obdélníkový:450x600 (2)
In: 2NP
Type - Pset_BeamCommon - LoadBearing: yes
Material: Beton prostý, C30/37
Pset_BeamCommon - IsExternal: no; Slope: 0 deg; Reference: 450x600
Pset_QuantityTakeOff - Reference: 450x600; sets with these values: 2
Name (Trám_Obdélníkový:450x600:...) | Span (mm)
509640 | 24435
509736 | 24415

# IfcBuildingElementProxy: stredovy_průvlak:stredovy_průvlak (6)
In: SHK 2NP
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: stredovy_průvlak; sets with these values: 2
Name (stredovy_průvlak:stredovy_průvlak:...)
508228
508464
508472
508482
508490
508498

# IfcBuildingElementProxy: vaznik:vaznik (20)
In: Střecha-nové
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: vaznik; sets with these values: 2
Name (vaznik:vaznik:...) | Group
534208 | Modelová skupina:Skupina polí 1:535327
535330 | Modelová skupina:Skupina polí 1:535331
535353 | Modelová skupina:Skupina polí 1:535354
535356 | Modelová skupina:Skupina polí 1:535357
535359 | Modelová skupina:Skupina polí 1:535360
535362 | Modelová skupina:Skupina polí 1:535363
535365 | Modelová skupina:Skupina polí 1:535366
535368 | Modelová skupina:Skupina polí 1:535369
535371 | Modelová skupina:Skupina polí 1:535372
535374 | Modelová skupina:Skupina polí 1:535375
535377 | Modelová skupina:Skupina polí 1:535378
535380 | Modelová skupina:Skupina polí 1:535381
535383 | Modelová skupina:Skupina polí 1:535384
535386 | Modelová skupina:Skupina polí 1:535387
535389 | Modelová skupina:Skupina polí 1:535390
535392 | Modelová skupina:Skupina polí 1:535393
535395 | Modelová skupina:Skupina polí 1:535396
535398 | Modelová skupina:Skupina polí 1:535399
535401 | Modelová skupina:Skupina polí 1:535402
535404 | Modelová skupina:Skupina polí 1:535405

# IfcColumn: Sloup hranatý:350x500 (13)
Type - PredefinedType: COLUMN; Material: Beton prostý, C30/37
Type - Pset_ColumnCommon - LoadBearing: yes
Pset_ColumnCommon - IsExternal: no; Reference: 350x500
Pset_QuantityTakeOff - Reference: 350x500; sets with these values: 2
Name (Sloup hranatý:350x500:...) | In
506655 | SHK 1NP
511485 | HHK 2NP
511515 | HHK 2NP
511527 | HHK 2NP | Pset_ColumnCommon - Slope: 0 deg
511908 | HHK 2NP
511966 | HHK 2NP
512441 | HHK 2NP
512442 | 2NP
520203 | HHK 3NP | Pset_ColumnCommon - Slope: 0 deg
520283 | HHK 3NP | Pset_ColumnCommon - Slope: 0 deg
520449 | HHK 3NP
520661 | HHK 3NP
521049 | HHK 3NP | Pset_ColumnCommon - Slope: 0 deg

# IfcColumn: Sloup hranatý:400x400 (4)
Type - PredefinedType: COLUMN; Material: Beton prostý, C30/37
Type - Pset_ColumnCommon - LoadBearing: yes
Pset_ColumnCommon - IsExternal: no; Reference: 400x400
Pset_QuantityTakeOff - Reference: 400x400; sets with these values: 2
Name (Sloup hranatý:400x400:...) | In
511070 | HHK 2NP
511385 | HHK 2NP
520375 | HHK 3NP | Pset_ColumnCommon - Slope: 0 deg
520521 | HHK 3NP | Pset_ColumnCommon - Slope: 0 deg

# IfcColumn: Sloup hranatý:440x440 (30)
Type - PredefinedType: COLUMN; Material: Beton prostý, C30/37
Type - Pset_ColumnCommon - LoadBearing: yes
Pset_ColumnCommon - Reference: 440x440; IsExternal: no
Pset_QuantityTakeOff - Reference: 440x440; sets with these values: 2
Name (Sloup hranatý:440x440:...) | In
506058 | SHK 1NP
506487 | SHK 1NP
506495 | SHK 1NP
506507 | SHK 1NP
506515 | SHK 1NP | Pset_ColumnCommon - Slope: 0 deg
506527 | SHK 1NP | Pset_ColumnCommon - Slope: 0 deg
506541 | SHK 1NP
506551 | SHK 1NP
506561 | SHK 1NP
506571 | SHK 1NP
506581 | SHK 1NP
506591 | SHK 1NP
506623 | SHK 1NP
506635 | SHK 1NP
506645 | SHK 1NP
506669 | SHK 1NP
506679 | SHK 1NP
507008 | HHK 2NP
507009 | HHK 2NP
507010 | HHK 2NP
507011 | HHK 2NP
507012 | HHK 2NP
507013 | HHK 2NP | Pset_ColumnCommon - Slope: 0 deg
507014 | HHK 2NP | Pset_ColumnCommon - Slope: 0 deg
507015 | HHK 2NP | Pset_ColumnCommon - Slope: 0 deg
507016 | HHK 2NP | Pset_ColumnCommon - Slope: 0 deg
507017 | HHK 2NP | Pset_ColumnCommon - Slope: 0 deg
507018 | HHK 2NP | Pset_ColumnCommon - Slope: 0 deg
507019 | HHK 2NP | Pset_ColumnCommon - Slope: 0 deg
523023 | SHK 1NP

# IfcColumn: Sloup hranatý:450x450 (3)
In: HHK 3NP
Type - PredefinedType: COLUMN; Material: Beton prostý, C30/37
Type - Pset_ColumnCommon - LoadBearing: yes
Pset_ColumnCommon - IsExternal: no; Reference: 450x450
Pset_QuantityTakeOff - Reference: 450x450; sets with these values: 2
Name (Sloup hranatý:450x450:...) | Slope (deg)
521392
521474 | 0
521487 | 0

# IfcColumn: Sloup hranatý:450x500 (2)
In: HHK 3NP
Type - PredefinedType: COLUMN; Material: Beton prostý, C30/37
Type - Pset_ColumnCommon - LoadBearing: yes
Pset_ColumnCommon - IsExternal: no; Reference: 450x500
Pset_QuantityTakeOff - Reference: 450x500; sets with these values: 2
Name (Sloup hranatý:450x500:...)
520789 | Pset_ColumnCommon - Slope: 0 deg
520939

# IfcReinforcingBar: Tyč výztuže:10 (89)
NominalDiameter: 10 mm; CrossSectionArea: 0.0000785398 m2; Material: B 500B tmavá modrá
Pset_QuantityTakeOff - Reference: 10
Pset_ReinforcingBarBendingsISOCD3766Common - ISOCD3766ShapeCode: Třmínek uzavřený; ISOCD3766BendingStartHook: 135 deg; ISOCD3766BendingEndHook: 135 deg; ISOCD3766ShapeParameter_b: 200 mm; ISOCD3766ShapeParameter_c: 78.9049 mm; ISOCD3766ShapeParameter_d: 78.9049 mm
Name (Tyč výztuže:10 : Tvar Třmínek uzavřený:...) | In | BarLength (mm) | ISOCD3766ShapeParameter_a (mm)
544719 | 3NP | 1395 | 450
545138 | 3NP | 1395 | 450
545183 | 3NP | 1395 | 450
545225 | 3NP | 1395 | 450
547477 | 3NP | 1395 | 450
547695 | 3NP | 1395 | 450
547753 | 3NP | 1395 | 450
548054 | 3NP | 1395 | 450
548055 | 3NP | 1395 | 450
548145 | 3NP | 1395 | 450
548811 | 3NP | 1395 | 450
553367 | 3NP | 1395 | 450
553368 | 3NP | 1395 | 450
553369 | 3NP | 1395 | 450
553545 | 3NP | 1395 | 450
553580 | 3NP | 1395 | 450
553666 | 3NP | 1395 | 450
556455 | 3NP | 1395 | 450
556456 | 3NP | 1395 | 450
556457 | 3NP | 1395 | 450
558701 | 3NP | 1395 | 450
558702 | 3NP | 1395 | 450
559876 | 3NP | 1395 | 450
559957 | 3NP | 1395 | 450
560071 | 3NP | 1395 | 450
560157 | 3NP | 1395 | 450
561660 | 3NP | 1295 | 400
563364 | 3NP | 1295 | 400
563654 | 3NP | 1295 | 400
564212 | 3NP | 1295 | 400
564999 | 3NP | 1295 | 400
567788 | 3NP | 1295 | 400
567925 | 3NP | 1295 | 400
567971 | 3NP | 1295 | 400
568050 | 3NP | 1295 | 400
568183 | 3NP | 1295 | 400
568214 | 3NP | 1295 | 400
568424 | 3NP | 1295 | 400
568578 | 3NP | 1295 | 400
568693 | 3NP | 1295 | 400
568833 | 3NP | 1295 | 400
568939 | 3NP | 1295 | 400
569686 | 3NP | 1395 | 450
569688 | 3NP | 1395 | 450
569689 | 3NP | 1395 | 450
569690 | 3NP | 1395 | 450
569691 | 3NP | 1395 | 450
569879 | 3NP | 1395 | 450
569880 | 3NP | 1395 | 450
569882 | 3NP | 1395 | 450
569883 | 3NP | 1395 | 450
570867 | 3NP | 1295 | 400
579154 | SHK 3NP | 1395 | 450
579155 | SHK 3NP | 1395 | 450
579156 | SHK 3NP | 1395 | 450
579158 | SHK 3NP | 1395 | 450
579159 | SHK 3NP | 1395 | 450
579160 | SHK 3NP | 1395 | 450
579161 | SHK 3NP | 1395 | 450
579162 | SHK 3NP | 1395 | 450
579163 | SHK 3NP | 1395 | 450
579164 | SHK 3NP | 1395 | 450
579165 | SHK 3NP | 1395 | 450
579166 | SHK 3NP | 1395 | 450
579167 | SHK 3NP | 1395 | 450
579168 | SHK 3NP | 1395 | 450
579169 | SHK 3NP | 1395 | 450
579170 | SHK 3NP | 1395 | 450
579171 | SHK 3NP | 1395 | 450
581445 | SHK 3NP | 1395 | 450
581446 | SHK 3NP | 1395 | 450
581447 | SHK 3NP | 1395 | 450
581448 | SHK 3NP | 1395 | 450
581449 | SHK 3NP | 1395 | 450
581591 | HHK 3NP | 1395 | 450
581592 | HHK 3NP | 1395 | 450
581593 | HHK 3NP | 1395 | 450
581594 | HHK 3NP | 1395 | 450
581595 | HHK 3NP | 1395 | 450
583940 | SHK 3NP | 1395 | 450
583941 | SHK 3NP | 1395 | 450
583942 | SHK 3NP | 1395 | 450
583943 | SHK 3NP | 1395 | 450
583944 | SHK 3NP | 1395 | 450
583945 | HHK 3NP | 1395 | 450
583946 | HHK 3NP | 1395 | 450
583947 | HHK 3NP | 1395 | 450
583948 | HHK 3NP | 1395 | 450
583949 | HHK 3NP | 1395 | 450

# IfcReinforcingBar: Tyč výztuže:18 (38)
NominalDiameter: 18 mm; CrossSectionArea: 0.000254469 m2; Material: B 500B oranž
Pset_QuantityTakeOff - Reference: 18
Pset_ReinforcingBarBendingsISOCD3766Common - ISOCD3766ShapeCode: 01
Name (Tyč výztuže:18 : Tvar 01:...) | In | BarLength (mm) = ISOCD3766ShapeParameter_a (mm)
543079 | HHK 3NP | 2790
543343 | HHK 3NP | 2790
543887 | HHK 3NP | 2790
544053 | HHK 3NP | 2790
544296 | HHK 3NP | 2790
544297 | HHK 3NP | 2790
544310 | HHK 3NP | 2790
544311 | HHK 3NP | 2790
544376 | HHK 3NP | 2790
544377 | HHK 3NP | 2790
557956 | 3NP | 2645
557957 | 3NP | 2645
562940 | HHK 3NP | 2790
562941 | HHK 3NP | 2865
566610 | HHK 3NP | 2790
566611 | HHK 3NP | 2790
567077 | HHK 3NP | 2790
567078 | HHK 3NP | 2790
567090 | HHK 3NP | 2790
567091 | HHK 3NP | 2790
567105 | HHK 3NP | 2865
567106 | HHK 3NP | 2865
569614 | HHK 3NP | 2790
569615 | HHK 3NP | 2790
578269 | HHK 2NP | 3005
578270 | HHK 2NP | 3005
578564 | HHK 2NP | 3005
578565 | HHK 2NP | 3005
578581 | HHK 2NP | 3005
578582 | HHK 2NP | 3005
578629 | HHK 2NP | 3000
578630 | HHK 2NP | 3000
578801 | HHK 2NP | 3000
578802 | HHK 2NP | 3000
582980 | HHK 2NP | 2990
582981 | HHK 2NP | 2990
584077 | HHK 2NP | 2990
584078 | HHK 2NP | 2990

# IfcReinforcingBar: Tyč výztuže:20 (90)
NominalDiameter: 20 mm; CrossSectionArea: 0.000314159 m2; Material: B 500B
Pset_QuantityTakeOff - Reference: 20
Name (Tyč výztuže:20 :...) | In | BarLength (mm) | ISOCD3766ShapeCode | ISOCD3766ShapeParameter_a (mm) | ISOCD3766ShapeParameter_b (mm)
 Tvar 01:552273 | 3NP | 1400 | 01 | 1400
 Tvar 01:553034 | 3NP | 1400 | 01 | 1400
 Tvar 01:553047 | 3NP | 1400 | 01 | 1400
 Tvar 01:553260 | 3NP | 1400 | 01 | 1400
 Tvar 11:554698 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:555035 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:555053 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:555054 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:555108 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:555109 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:555110 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:555111 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:555122 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:555123 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:555124 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:555125 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 01:559541 | 3NP | 1400 | 01 | 1400
 Tvar 01:560683 | 3NP | 1400 | 01 | 1400
 Tvar 11:562229 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:562230 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:562303 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:562680 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:562756 | 3NP | 1660 | 11 | 721 | 1000
 Tvar 11:562757 | 3NP | 1660 | 11 | 721 | 1000
 Tvar 11:562758 | 3NP | 1660 | 11 | 721 | 1000
 Tvar 11:562759 | 3NP | 1660 | 11 | 721 | 1000
 Tvar 01:565805 | 3NP | 1400 | 01 | 1400
 Tvar 01:566387 | 3NP | 1400 | 01 | 1400
 Tvar 01:566400 | 3NP | 1400 | 01 | 1400
 Tvar 01:566413 | 3NP | 1400 | 01 | 1400
 Tvar 11:567347 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:567348 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:567349 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:567350 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:567455 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:567456 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:567457 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:567458 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:567473 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:567474 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:567475 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:567476 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:567493 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:567494 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:567532 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:567670 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:569479 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:569480 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:569481 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:569482 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:569692 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:569693 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:569694 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:569695 | 3NP | 1665 | 11 | 721 | 1001
 Tvar 11:570331 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:570332 | 3NP | 1660 | 11 | 721 | 1000
 Tvar 11:570333 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 11:570334 | 3NP | 1660 | 11 | 720 | 1000
 Tvar 01:578900 | HHK 3NP | 1400 | 01 | 1400
 Tvar 01:578901 | HHK 3NP | 1400 | 01 | 1400
 Tvar 01:578902 | HHK 3NP | 1400 | 01 | 1400
 Tvar 01:578903 | HHK 3NP | 1400 | 01 | 1400
 Tvar 01:579221 | 2NP | 1850 | 01 | 1850
 Tvar 01:579746 | 2NP | 1850 | 01 | 1850
 Tvar 01:579789 | 2NP | 1850 | 01 | 1850
 Tvar 01:579790 | 2NP | 1850 | 01 | 1850
 Tvar 01:579808 | 2NP | 1850 | 01 | 1850
 Tvar 01:579809 | 2NP | 1850 | 01 | 1850
 Tvar 01:579826 | 2NP | 1850 | 01 | 1850
 Tvar 01:580269 | 2NP | 1850 | 01 | 1850
 Tvar 01:580324 | 2NP | 1850 | 01 | 1850
 Tvar 01:580325 | 2NP | 1850 | 01 | 1850
 Tvar 01:580565 | HHK 3NP | 1400 | 01 | 1400
 Tvar 01:582544 | 2NP | 2000 | 01 | 2000
 Tvar 01:582545 | 2NP | 2000 | 01 | 2000
 Tvar 11:583552 | 2NP | 1660 | 11 | 721 | 1000
 Tvar 11:583553 | 2NP | 1660 | 11 | 721 | 1000
 Tvar 11:583554 | 2NP | 1660 | 11 | 721 | 1000
 Tvar 11:583555 | 2NP | 1660 | 11 | 721 | 1000
 Tvar 01:583931 | HHK 3NP | 1400 | 01 | 1400
 Tvar 01:583951 | 2NP | 2000 | 01 | 2000
 Tvar 01:583952 | 2NP | 2000 | 01 | 2000
 Tvar 11:583953 | 2NP | 1660 | 11 | 721 | 1000
 Tvar 11:583954 | 2NP | 1660 | 11 | 721 | 1000
 Tvar 11:583955 | 2NP | 1660 | 11 | 721 | 1000
 Tvar 11:583956 | 2NP | 1660 | 11 | 721 | 1000
 Tvar 01:587679 | 2NP | 1850 | 01 | 1850
 Tvar 01:587680 | 2NP | 1850 | 01 | 1850
 Tvar 01:614611 | 3NP | 1400 | 01 | 1400
 Tvar 01:614685 | 3NP | 1400 | 01 | 1400

# IfcReinforcingBar: Tyč výztuže:22 (54)
NominalDiameter: 22 mm; CrossSectionArea: 0.000380133 m2; Material: B 500B zelená
Pset_QuantityTakeOff - Reference: 22
Pset_ReinforcingBarBendingsISOCD3766Common - ISOCD3766ShapeCode: 01
Name (Tyč výztuže:22 : Tvar 01:...) | In | BarLength (mm) | ISOCD3766ShapeParameter_a (mm)
545288 | 3NP | 5275 | 5274.6
546140 | 3NP | 4290 | 4290
546320 | 3NP | 5275 | 5274.6
546411 | 3NP | 4275 | 4277.3
554276 | 3NP | 450 | 450
554498 | 3NP | 450 | 450
554660 | 3NP | 450 | 450
554661 | 3NP | 450 | 450
554672 | 3NP | 450 | 450
554673 | 3NP | 450 | 450
556607 | 3NP | 6075 | 6075
557958 | 3NP | 450 | 450
557959 | 3NP | 450 | 450
559595 | 3NP | 3400 | 3400
561658 | 3NP | 2940 | 2940
563189 | 3NP | 400 | 400
565423 | 3NP | 4770 | 4770
565465 | 3NP | 4785 | 4785
565500 | 3NP | 6625 | 6625
565536 | 3NP | 400 | 400
565658 | 3NP | 400 | 400
565692 | 3NP | 400 | 400
565693 | 3NP | 400 | 400
565704 | 3NP | 400 | 400
565705 | 3NP | 400 | 400
565717 | 3NP | 400 | 400
569616 | 3NP | 450 | 450
569617 | 3NP | 450 | 450
569807 | 3NP | 6075 | 6075
569809 | 3NP | 3400 | 3400
572434 | 3NP | 450 | 450
572517 | 3NP | 450 | 450
578891 | SHK 3NP | 5275 | 5274.6
578893 | SHK 3NP | 4290 | 4290
578895 | SHK 3NP | 5275 | 5274.6
578897 | SHK 3NP | 4275 | 4277.3
579042 | SHK 3NP | 450 | 450
579043 | SHK 3NP | 450 | 450
579044 | SHK 3NP | 450 | 450
579045 | SHK 3NP | 450 | 450
579046 | SHK 3NP | 450 | 450
579047 | SHK 3NP | 450 | 450
579048 | SHK 3NP | 450 | 450
579049 | SHK 3NP | 450 | 450
580563 | SHK 3NP | 6240 | 6240
580612 | SHK 3NP | 450 | 450
580942 | HHK 3NP | 450 | 450
581194 | 3NP | 450 | 450
581764 | 3NP | 450 | 450
583929 | SHK 3NP | 6240 | 6240
583932 | SHK 3NP | 450 | 450
583935 | HHK 3NP | 450 | 450
583936 | 3NP | 450 | 450
583950 | 3NP | 450 | 450

# IfcReinforcingBar: Tyč výztuže:25 (40)
NominalDiameter: 25 mm; CrossSectionArea: 0.000490874 m2; Material: B 500B tmavá fiala
Pset_QuantityTakeOff - Reference: 25
Pset_ReinforcingBarBendingsISOCD3766Common - ISOCD3766ShapeCode: 01
Name (Tyč výztuže:25 : Tvar 01:...) | In | BarLength (mm) | ISOCD3766ShapeParameter_a (mm)
545635 | 3NP | 4655 | 4655
546141 | 3NP | 2225 | 2225
546321 | 3NP | 5260 | 5260
546412 | 3NP | 4675 | 4675
551874 | 3NP | 2225 | 2225
556517 | 3NP | 2905 | 2905.05
556889 | 3NP | 1475 | 1475
557595 | 3NP | 1475 | 1475
559373 | 3NP | 4950 | 4949.81
560595 | 3NP | 1610 | 1609.77
561355 | 3NP | 1200 | 1200
561356 | 3NP | 1200 | 1200
561659 | 3NP | 1590 | 1590
565112 | 3NP | 3725 | 3725
565233 | 3NP | 4780 | 4777.5
565261 | 3NP | 5575 | 5575
565289 | 3NP | 3435 | 3432.5
569747 | 3NP | 2905 | 2905.05
569749 | 3NP | 4950 | 4949.81
569750 | 3NP | 1610 | 1609.77
569939 | 3NP | 1475 | 1475
569940 | 3NP | 1475 | 1475
570947 | 3NP | 1200 | 1200
570948 | 3NP | 1200 | 1200
578892 | HHK 3NP | 4655 | 4655
578894 | HHK 3NP | 2225 | 2225
578896 | HHK 3NP | 5260 | 5260
578898 | HHK 3NP | 4675 | 4675
578899 | HHK 3NP | 2225 | 2225
580562 | HHK 3NP | 2905 | 2905.05
580564 | HHK 3NP | 7005 | 7005.04
580691 | 3NP | 3990 | 3989.94
581376 | HHK 3NP | 1475 | 1475
581377 | SHK 3NP | 1475 | 1475
583928 | HHK 3NP | 2905 | 2905.05
583930 | HHK 3NP | 7005 | 7005.04
583933 | 3NP | 3990 | 3989.94
583937 | HHK 3NP | 1475 | 1475
583938 | SHK 3NP | 1475 | 1475
614563 | 3NP | 1610 | 1609.77

# IfcReinforcingBar: Tyč výztuže:8 (19)
NominalDiameter: 8 mm; CrossSectionArea: 0.0000502655 m2; Material: B 500B modrá
Pset_QuantityTakeOff - Reference: 8
Pset_ReinforcingBarBendingsISOCD3766Common - ISOCD3766ShapeCode: Třmínek uzavřený; ISOCD3766ShapeParameter_c: 63.1239 mm; ISOCD3766ShapeParameter_d: 63.1239 mm; ISOCD3766BendingStartHook: 135 deg; ISOCD3766BendingEndHook: 135 deg
Name (Tyč výztuže:8 : Tvar Třmínek uzavřený:...) | In | BarLength (mm) | ISOCD3766ShapeParameter_a (mm) | ISOCD3766ShapeParameter_b (mm)
542729 | 3NP | 1475 | 350 | 350
543618 | 3NP | 1575 | 300 | 450
544294 | 3NP | 1575 | 300 | 450
544309 | 3NP | 1575 | 300 | 450
544375 | 3NP | 1475 | 350 | 350
557955 | 3NP | 1575 | 300 | 450
562939 | 3NP | 1725 | 450 | 375
566609 | 3NP | 1675 | 400 | 400
567076 | 3NP | 1675 | 400 | 400
567089 | 3NP | 1675 | 400 | 400
567104 | 3NP | 1775 | 450 | 400
569613 | 3NP | 1575 | 300 | 450
578267 | HHK 2NP | 1575 | 300 | 450
578563 | HHK 2NP | 1575 | 300 | 450
578580 | HHK 2NP | 1575 | 300 | 450
578628 | HHK 2NP | 1475 | 350 | 350
578800 | HHK 2NP | 1475 | 350 | 350
583344 | HHK 2NP | 1575 | 300 | 450
584079 | HHK 2NP | 1575 | 300 | 450
